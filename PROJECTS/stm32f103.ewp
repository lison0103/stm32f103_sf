# IAR project stm32f103.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\HARDWARE\SPI; ..\HARDWARE\CAN; ..\HARDWARE\LED; ..\HARDWARE\EWDT; ..\SYSTEM; ..\APP
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f103.hex
  ILINK.IlinkOutputFile: stm32f103.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: hw_test.c
  group FWLib/CMSIS
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
    ../Libraries/CMSIS/: system_stm32f10x.c
  group FWLib/StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/EWDT/: ewdt.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group USER
    ./: main.c stm32f10x_conf.h stm32f10x_it.c
